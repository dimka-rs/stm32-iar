# IAR project Project.ewp, settings and files
configuration STM32L0xx_DISCO (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L053xx; USE_STM32L0XX_DISCO
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32L0538-Discovery; ..\..\..\..\..\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l053xx.s
  group Application/User
    ../Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/COMPONENT
    ../../../../../Drivers/BSP/Components/gde021a1/: gde021a1.c
  group Drivers/BSP/STM32L0xx_DISCO
    ../../../../../Drivers/BSP/STM32L0538-Discovery/: stm32l0538_discovery.c stm32l0538_discovery_epd.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
